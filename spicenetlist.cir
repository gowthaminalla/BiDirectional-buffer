** GPIO.ckt **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Gowthami
* Tue, Jun 16, 2020 22:42:50
*

*## Multisim Component V1 ##*
vV1 8 0 dc 12 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component U2 ##*
aU2 U2_OPEN_OUT d_constsource_U2
.model d_constsource_U2   d_constsource(state=0)

*## Multisim Component U1 ##*
xU1 dU1.1 DIGITAL_CLOCK__DIGITAL_SOURCES__1 PARAMS: Frequency=1000 Duty=50 Delay=0

xU1.1 dU1.1 1 TIL_DRV__NON__1

*## Multisim Component Venable ##*
aVenable dVenable.A dVenable.Y NOT__TIL__1

xVenable.Y dVenable.Y 6 TIL_DRV__NON__1

xVenable.A 1 dVenable.A TIL_RCV__NON__1

*## Multisim Component NMOS ##*
mNMOS 2 8 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component NMOS3 ##*
mNMOS3 8 4 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component NMOS4 ##*
mNMOS4 4 3 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component PMOS3 ##*
mPMOS3 8 4 6 6 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component PMOS4 ##*
mPMOS4 4 3 6 6 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component NMOS2 ##*
mNMOS2 3 2 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component PMOS2 ##*
mPMOS2 3 2 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component PMOS ##*
mPMOS 2 8 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

.SUBCKT TIL_DRV__NON__1 1 2
* TIL Driver Model  1 = D/A input, 2 = out
 aDACin1 [1] [2] aDAC
.MODEL aDAC dac_bridge (out_low= 0 out_high = 5 out_undef = 2.5)
.ENDS

.SUBCKT TIL_RCV__NON__1 1 2
* TIL Receiver Model  1 = input, 2 = A/D out
 aADCin1 [1] [2] ADC
.MODEL ADC adc_bridge (in_low= 2.5 in_high = 2.5)
.ENDS

.MODEL NOT__TIL__1 d_inverter (rise_delay = 1n fall_delay = 1n)

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos

.subckt DIGITAL_CLOCK__DIGITAL_SOURCES__1 out PARAMS: Frequency=1k Duty=50 Delay=0
A1 out DigClock
.model DigClock d_clock (frequency={Frequency} duty={Duty/100} delay={Delay})
.ends

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos
